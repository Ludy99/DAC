# Keil uVision project DLQ.uvprojx, settings and files
target DLQ (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\User;.\Delay;.\SineWave
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dac.c
  group Startup
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Delay
    ./Delay/: Delay.c
  group SineWave
    ./SineWave/: SineWave1.c
