# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SYSTEM;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dac.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_gpio.c
  group BSP
    ../BSP/: SineWave1.c
